#include <HardwareTimer.h>

#include "KS015.h"
#include "HeartbeatLED.h"


KS015 *KS015::instance = nullptr;

// Define the static alert callback
AlertCallback KS015::alert_cb = nullptr;

// Create a HardwareTimer instance for TIM4
HardwareTimer *Timer4 = new HardwareTimer(TIM4);


/**
 * Constructor
 * Initializes the CurrentSense channels array.
 * Uses initializer list to directly construct objects with parameters.
 */
KS015::KS015()
    : channels{ 
        CurrentSense(CH1_I2C_ADDRESS, CH1_ALERT_PIN, CH1_SW_PIN, KS015::Alert1_ISR),
        CurrentSense(CH2_I2C_ADDRESS, CH2_ALERT_PIN, CH2_SW_PIN, KS015::Alert2_ISR)
      },
      heartbeat(HEARTBEAT_LED_PIN)
{ 
  instance = this;

  Timer4->attachInterrupt(KS015::Timer4_ISR);      // Attach the interrupt handler to TIM4
  Timer4->setOverflow(1000, HERTZ_FORMAT);  // Set the timer to trigger every 1ms (1000 Hz)
  Timer4->resume();     // Start the timer

}

/**
 * begin()
 * Initializes the KS015 PCBA hardware.
 * - Starts Serial for debugging and control
 * - Initializes each INA260 current-sensing channel
 * - Prints initialization status for each channel
 * - Initializes the heartbeat LED
 */
void KS015::begin() {
    Serial.begin(230400);
    delay(5000);  // big delay to allow PC to reconnect to port

    char str[50];
    bool init_ok;

    // Initialize all channels
    for(uint8_t i=0; i<NUM_CHANNELS; i++)
    {
      init_ok = channels[i].begin();  // Initializes INA260 and pin configuration
      sprintf(str, "INA260 Address 0x%02x Initialisation %s", 
              channels[i].i2c_addr, 
              (init_ok) ? "OK" : "FAILED");
      Serial.println(str);
    }

    // Initialize the heartbeat LED
    heartbeat.begin();
}

/**
 * showInformation()
 * Return a string showing important information about the KS015.
 */
const char *KS015::showInformation(void) {
  static const char info[] = {
    "hello world\nthis is a second line"
  };
  return info;
}

/**
 * updateHeartbeat()
 * Implements a simple LED heartbeat pattern using a counter.
 * - LED toggles on/off at specific counts
 * - Delay of 1ms per count
 * Note: This is blocking;
 */
void KS015::updateHeartbeat() {
    static uint16_t cnt = 1;

    switch(cnt)
    {
      case 1:
      case 200:
        heartbeat.on();
        break;
      case 100:
      case 300:
        heartbeat.off();
        break;
      case 1000:
        cnt = 0;
        break;
    }
    cnt++;
}

/**
 * enableOutput(ch)
 * Turns on the output switch for the specified channel.
 */
 void KS015::enableOutput(KS015_Channel ch) {
    if(ch < NUM_CHANNELS) channels[ch].switchOn();
}

/**
 * disableOutput(ch)
 * Turns off the output switch for the specified channel.
 */
void KS015::disableOutput(KS015_Channel ch) {
    if(ch < NUM_CHANNELS) channels[ch].switchOff();
}

/**
 * getCurrent(ch)
 * Returns the measured current (in mA) for the specified channel.
 */
float KS015::getCurrent(KS015_Channel ch) {
    if(ch < NUM_CHANNELS) return channels[ch].readCurrent();
    return 0;
}

/**
 * getVoltage(ch)
 * Returns the bus voltage (in V) for the specified channel.
 */
float KS015::getVoltage(KS015_Channel ch) {
    if(ch < NUM_CHANNELS) return channels[ch].readVoltage();
    return 0;
}

/**
 * getPower(ch)
 * Returns the measured power (in mW) for the specified channel.
 */
float KS015::getPower(KS015_Channel ch) {
    if(ch < NUM_CHANNELS) return channels[ch].readPower();
    return 0;
}

/**
 * setAlertCallback(cb)
 * Registers a user-defined callback function that is triggered in response
 * to an alert event.
 */
void KS015::setAlertCallback(AlertCallback cb) {
    alert_cb = cb;
}


// Private helper to handle alert events
void KS015::handleAlert(KS015_Channel ch) {
    if (alert_cb) {
        alert_cb(ch);       // Call user-registered callback
    } else {
        // Fallback message for debug if no callback is registered
        Serial.print("KS015 Alert on CH");
        Serial.println(static_cast<int>(ch) + 1);
    }
}

/**
 * Alert1_ISR()
 * Interrupt Service Routine for channel 1 alert detection.
 */
void KS015::Alert1_ISR() {
  if (instance) {
    instance->handleAlert(CHANNEL1);
  }
}

/**
 * Alert2_ISR()
 * Interrupt Service Routine for channel 2 alert detection.
 */
void KS015::Alert2_ISR() {
  if (instance) {
    instance->handleAlert(CHANNEL2);
  }
}

/**
 * Timer4 ISR
 * Monitors the 2 channels and checks for any dangerous conditions that may result in 
 * overheating the switch MOSFET
 */
void KS015::Timer4_ISR() {
  // This function is called every time the timer interrupt fires
  static uint16_t secs = 0;
  if(++secs >= 1000)
  {
    secs = 0;
  }

  if (instance)
  {
    instance->updateHeartbeat();
  }
}

